Commit message: fixed the resetting issue, now to convert pointmass version to not having an arm

File: pandaRL/envs/lego/lego.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link legobrick: mass .1 -> 10.1
