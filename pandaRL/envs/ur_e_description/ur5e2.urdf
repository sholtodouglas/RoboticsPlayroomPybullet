Commit message: -

File: pandaRL/envs/ur_e_description/ur5e2.urdf (robot description, URDF)
Before this commit: robot ur5e, 23 links, 22 joints
Joints:
- joint grasptarget_hand: origin xyz=0 0.25 0.0 rpy=1.57 1.57 0 -> xyz=0 0.25 0.0 rpy=1.57 0 0
